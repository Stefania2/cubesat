options:
  parameters:
    author: Mayelin Stefania Aguilar Vasquez
    description: Cadena BPSK STRAND-1 corregida - cada byte del .bin es un bit (sin Unpack Bits), RRC matched, AWGN con SNR configurable y BER determinista.
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: cadena_strand1_awgn
    output_language: python
    title: Cadena BPSK STRAND-1 (bits sueltos, RRC, AWGN)
  states: {}

blocks:
- name: import_os
  id: import
  parameters:
    comment: Resuelve la ruta del .bin sin depender del directorio de trabajo
    imports: import os
  states: {}
- name: ruta_base
  id: variable
  parameters:
    comment: Carpeta donde vive este flowgraph
    value: os.path.dirname(os.path.realpath(globals().get('__file__', '.')))
  states: {}
- name: snr_db
  id: variable_qtgui_range
  parameters:
    comment: Eb/N0 en dB para el canal AWGN (control interactivo)
    gui_hint: 1,0,1,1
    label: Eb/N0 (dB)
    start: '0.0'
    step: '0.5'
    stop: '12.0'
    value: '10.0'
  states: {}
- name: noise_amp
  id: variable
  parameters:
    comment: Amplitud del ruido AWGN calibrada para Eb/N0 pedido (A/(KAPPA*sqrt(2*10^(snr/10))))
    value: A/(KAPPA*(2.0*10.0**(snr_db/10.0))**0.5)
  states: {}
- name: A
  id: variable
  parameters:
    comment: Amplitud de decision medida (pico del filtro matched, gain=8)
    value: '8.00011'
  states: {}
- name: KAPPA
  id: variable
  parameters:
    comment: Sigma_decision = KAPPA * noise_amp (medido empiricamente)
    value: '1.98733'
  states: {}
- name: N
  id: variable
  parameters:
    comment: Numero de bits de frames_STRAND1_bits.bin
    value: '18776'
  states: {}
- name: L
  id: variable
  parameters:
    comment: Cola de ceros para drenar el filtro TX ((ntaps-1)/sps)
    value: '11'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Frecuencia de muestreo = 9600 * 8
    value: '76800'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    comment: Tasa de simbolos = 9600 baudios
    value: '9600'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Muestras por simbolo
    value: '8'
  states: {}
- name: alpha
  id: variable
  parameters:
    comment: Factor de roll-off del filtro RRC
    value: '0.35'
  states: {}
- name: ntaps
  id: variable
  parameters:
    comment: Numero de taps del RRC (8*11+1)
    value: '89'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Suma senal + ruido (canal AWGN en banda base compleja)
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    comment: Ruido AWGN Gaussiano complejo (amplitud calibrada)
    noise_type: analog.GR_GAUSSIAN
    seed: '11'
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    comment: Extrae componente I (real)
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: Sintoniza la fase de decimacion a 1 de cada 8 (pico del matched)
    delay: '7'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Bits recuperados (1 byte = 1 bit)
    file: os.path.join(ruta_base, 'frames_STRAND1_bits_rx.bin')
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Telemetria real STRAND-1 (18.776 bytes, cada byte es un bit 0/1)
    file: os.path.join(ruta_base, 'frames_STRAND1_bits.bin')
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: Convierte a complejo (I = senal RRC, Q = 0)
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: Diezma 8:1 tomando la ultima muestra (muestreo de simbolo)
    n: sps
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: Descarta el transitorio del filtro (Dg = ntaps-1)
    num_items: '11'
    type: float
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    comment: Concatena bits + cola de ceros para drenar el filtro TX
    lengths: (N, L)
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    comment: Control de velocidad para visualizacion en tiempo real
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Cola de L ceros (drena la respuesta del filtro TX)
    repeat: 'False'
    type: byte
    vector: '[0]*L'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters:
    comment: 'Decide bit: 0 si < 0, 1 si >= 0'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: 'Mapeo BPSK: bit 0 -> -1, bit 1 -> +1 (sin expandir bytes)'
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1.0, 1.0]'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: Constelacion BPSK con ruido AWGN
    grid: 'True'
    gui_hint: 0,0,1,1
    name: Constelacion
    size: '1024'
    type: complex
    update_time: '0.05'
    xmax: '12.0'
    xmin: '-12.0'
    ymax: '12.0'
    ymin: '-12.0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Simbolos muestreados antes de la decision
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: Simbolos
    marker1: '0'
    name: Simbolos RX
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    style1: '4'
    type: float
    update_time: '0.05'
    ymax: '12.0'
    ymin: '-12.0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    comment: Filtro conformador RRC TX (interpolador 8:1)
    gain: sps
    interp: sps
    ntaps: ntaps
    samp_rate: samp_rate
    sym_rate: sym_rate
    type: interp_fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    comment: Filtro matched RRC RX
    decim: '1'
    gain: sps
    ntaps: ntaps
    samp_rate: samp_rate
    sym_rate: sym_rate
    type: fir_filter_fff
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', root_raised_cosine_filter_1, '0']
- [blocks_delay_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_file_source_0, '0', blocks_stream_mux_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_skiphead_0, '0']
- [blocks_skiphead_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_skiphead_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_mux_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '1']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_float_to_complex_0, '0']
- [root_raised_cosine_filter_1, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
