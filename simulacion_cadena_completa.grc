options:
  parameters:
    author: Mayelin Stefania Aguilar Vasquez
    description: Cadena completa de transmision y recepcion BPSK con telemetria real STRaND-1.
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: simulacion_cadena_completa
    output_language: python
    title: Cadena Completa BPSK - CubeSat STRaND-1
  states: {}

blocks:
- name: import_os
  id: import
  parameters:
    comment: Para resolver la ruta del .bin sin depender del directorio de trabajo
    imports: import os
  states: {}
- name: ruta_base
  id: variable
  parameters:
    comment: Carpeta donde vive este flowgraph
    value: os.path.dirname(os.path.realpath(globals().get('__file__', '.')))
  states: {}
- name: noise_amplitude
  id: variable_qtgui_range
  parameters:
    comment: Control interactivo de amplitud de ruido AWGN
    gui_hint: 0,0,1,1
    label: Amplitud de ruido AWGN
    start: '0.0'
    step: '0.01'
    stop: '0.5'
    value: '0.05'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Frecuencia de muestreo = 9600 * 8
    value: '76800'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Muestras por simbolo
    value: '8'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    comment: Tasa de simbolos = 9600 baudios
    value: '9600'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amplitude
    comment: Fuente de ruido AWGN Gaussiano complejo
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Suma senal + ruido (canal AWGN]
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    comment: Extrae componente I (real]
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Carga bytes de telemetria real STRaND-1
    file: os.path.join(ruta_base, 'frames_STRAND1_gnuradio.bin')
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: 'Convierte a complejo: I = senal, Q = 0'
  states: {}
- name: blocks_integrate_ff_0
  id: blocks_integrate_xx
  parameters:
    comment: Integra (suma] 8 muestras por simbolo y diezma
    decim: sps
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: Consume bits recuperados
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: 'Sobremuestreo: 8 muestras por simbolo'
    interp: sps
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    comment: Control de velocidad de procesamiento
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters:
    comment: Convierte byte a float para visualizar
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Convierte cada byte en 8 bits individuales (0/1]
    k: '8'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters:
    comment: 'Decide bit: 0 si < 0, 1 si >= 0'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: 'Mapeo BPSK NRZ: bit 0 -> -1, bit 1 -> +1'
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1.0, 1.0]'
  states: {}
- name: iio_fmcomms2_sink_0
  id: iio_fmcomms2_sink
  parameters:
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    rf_port_select: '''A'''
    samplerate: samp_rate
    tx1_en: 'True'
    tx2_en: 'True'
    type: fc32
    uri: 'local:'
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: Constelacion BPSK
    grid: 'True'
    gui_hint: 2,1,1,1
    name: Constelacion
    size: '1024'
    type: complex
    update_time: '0.05'
    xmax: '2.0'
    xmin: '-2.0'
    ymax: '2.0'
    ymin: '-2.0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Espectro de la senal BPSK
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,1,1,1
    label: Espectro
    label1: BPSK
    name: Espectro
    type: complex
    update_time: '0.05'
    ymin: '-60'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Forma de onda BPSK transmitida
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: I (Real]
    label2: Q (Imag]
    marker1: '0'
    marker2: '0'
    name: TX
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.05'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Simbolos integrados antes de la decision
    grid: 'True'
    gui_hint: 0,2,1,1
    label1: Integrador
    marker1: '0'
    name: Simbolos
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
    update_time: '0.05'
    width1: '4'
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Bits recuperados por el binary slicer
    grid: 'True'
    gui_hint: 1,2,1,1
    label1: Bits
    marker1: '0'
    name: Bits RX
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
    update_time: '0.05'
    width1: '4'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', blocks_integrate_ff_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_integrate_ff_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_integrate_ff_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_repeat_0, '0', blocks_float_to_complex_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_null_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
