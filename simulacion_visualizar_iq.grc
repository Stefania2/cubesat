options:
  parameters:
    author: Mayelin Stefania Aguilar Vasquez
    description: Visualizacion de senales IQ pre-computadas del enlace RF CubeSat STRaND-1.
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: simulacion_visualizar_iq
    output_language: python
    title: Visualización de Señal IQ - CubeSat STRaND-1
  states: {}

blocks:
- name: import_os
  id: import
  parameters:
    comment: Para resolver la ruta del .bin sin depender del directorio de trabajo
    imports: import os
  states: {}
- name: ruta_base
  id: variable
  parameters:
    comment: Carpeta donde vive este flowgraph
    value: os.path.dirname(os.path.realpath(globals().get('__file__', '.')))
  states: {}
- name: noise_amplitude
  id: variable_qtgui_range
  parameters:
    comment: Control interactivo de la amplitud del ruido AWGN
    gui_hint: 0,0,1,1
    label: Amplitud de ruido
    start: '0.0'
    step: '0.005'
    stop: '0.5'
    value: '0.02'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Frecuencia de muestreo = 9600 bps * 8 muestras/simbolo
    value: '76800'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Muestras por simbolo
    value: '8'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    comment: Tasa de simbolos (baudios]
    value: '9600'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amplitude
    comment: Ruido AWGN Gaussiano complejo
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Suma senal + ruido
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Carga el archivo IQ BPSK pre-computado.
    file: os.path.join(ruta_base, 'resultados_simulacion', 'strand1_bpsk_iq_clean_complex64.bin')
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    comment: Limita la velocidad de procesamiento
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: Diagrama de constelacion
    grid: 'True'
    gui_hint: 2,1,1,1
    name: Constelacion
    size: '1024'
    type: complex
    update_time: '0.05'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Espectro de frecuencia
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,1,1,1
    label: Frecuencia
    label1: Senal
    name: Frecuencia
    type: complex
    update_time: '0.05'
    ymin: '-60'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Forma de onda temporal
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: I
    label2: Q
    marker1: '0'
    marker2: '0'
    name: Tiempo
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.05'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
